/* Includes ------------------------------------------------------------------*/
#include "tool.h"
#include "string.h"
/* 函数原型 ----------------------------------------------------------*/
/* 宏  ---------------------------------------------------------------*/
/* 变量 --------------------------------------------------------------*/
const uint8_t crc_h_table[] = {
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,  
0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,  
0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,  
0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,  
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81,  
0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,  
0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,  
0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,  
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,  
0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,  
0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,  
0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,  
0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,  
0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,  
0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,  
0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,  
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,  
0x40  
} ;
// CRC 低位字节值表
const uint8_t crc_l_table[] = {
0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7, 0x05, 0xC5, 0xC4,  
0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,  
0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD,  
0x1D, 0x1C, 0xDC, 0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,  
0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32, 0x36, 0xF6, 0xF7,  
0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,  
0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE,  
0x2E, 0x2F, 0xEF, 0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,  
0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1, 0x63, 0xA3, 0xA2,  
0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,  
0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB,  
0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,  
0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0, 0x50, 0x90, 0x91,  
0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,  
0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88,  
0x48, 0x49, 0x89, 0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,  
0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83, 0x41, 0x81, 0x80,  
0x40
};
/* 类型定义 ----------------------------------------------------------*/
/* 函数声明 ----------------------------------------------------------*/
/* 函数代码 ----------------------------------------------------------*/

/**
 * @brief: CRC校验
 * @param {type} None
 * @return: None
 */
uint16_t calc_crc16(uint8_t *buf, uint16_t len)
{
    uint8_t crc_h = 0xff;
    uint8_t crc_l = 0xff;     
    int index;

    while(len--)
    {
    	index = crc_h ^ *(buf++);  /*计算CRC*/
    	crc_h = (uint8_t)(crc_l ^ crc_h_table[index]);
    	crc_l = crc_l_table[index];
    }
    return ((uint16_t)crc_h << 8 | crc_l);
}

void find_symbol_split_to_string(uint8_t *str_buf,uint8_t *data,char symbol_split,uint8_t index)
{
	uint8_t flag = 0;
	uint16_t length = 0,cnt = 0;

	length = strlen((const char *)str_buf);
	if(length)
	{
		for(;cnt < length;cnt ++)
		{
			if(flag == index && str_buf[cnt] != symbol_split)
			{
				*data++ = str_buf[cnt];
			}
			else if(str_buf[cnt] == symbol_split)
			{
				if(++flag > index)
				{
					break;
				}
			}
		}
	}
	*data = '\0';
}

/**
  * @brief  两个数组比较 数组2是否为数组1的子数组
  * @param  buf  		数组1
  * @param  check_buf 	数组2
  * @param  size        数组1的长度
  * @retval 0:数组2是数组1的子数组       1:否
  */
uint8_t strstrlen(uint8_t *buf,uint8_t *check_buf, uint16_t size)
{
	uint16_t i = 0, j = 0, k = 0;
	for(i = 0;i < size; i++)
	{
		for(j = i;buf[j] == check_buf[k] && check_buf[k] != '\0'; j++, k++);
		if(j > 0 && check_buf[k] == '\0')
		{
			return 0;
		}
		k = 0;
	}
	return 1;
}



/**
  * @brief  两个数组比较 数组2是否为数组1的子数组
  * @param  buf  		数组1
  * @param  check_buf 	数组2
  * @param  size        数组1的长度
* @retval   返回数组2第一次出现的位置	
  */
uint16_t strstraddr(uint8_t *buf,uint8_t *check_buf, uint16_t size)
{
	uint16_t i = 0, j = 0, k = 0;
	for(i = 0;i < size; i++)
	{
		for(j = i;buf[j] == check_buf[k] && check_buf[k] != '\0'; j++, k++);
		if(j > 0 && check_buf[k] == '\0')
		{
			return i;
		}
		k = 0;
	}
	return 0xFFFF;
}

uint16_t be_buf_2_uint16(uint8_t *buf)
{
	return (((uint16_t)buf[0] << 8) | buf[1]);
}

uint32_t be_buf_2_uint32(uint8_t *buf)
{
	return (((uint32_t)buf[0] << 24) | ((uint32_t)buf[1] << 16) | ((uint32_t)buf[2] << 8) | buf[3]);
}

float be_buf_2_float(uint8_t *buf)
{
	float res = 0;
	uint8_t *rec;

	rec = (uint8_t *)&res;
	*rec = buf[3];rec++;
	*rec = buf[2];rec++;
	*rec = buf[1];rec++;
	*rec = buf[0];

	return res;
}

void hex16_to_str(uint8_t *s_inchar, uint16_t s_len, uint8_t  *a_outtxt)
{

	uint16_t size1=0,i=0;
		 for( size1=0;size1<s_len; size1++)
		{
			
			if(	s_inchar[size1]>='0' && s_inchar[size1] <= '9')
			{
				a_outtxt[size1] = s_inchar[size1] - 0x30;
			}
			else if(	s_inchar[size1]>='A' && s_inchar[size1] <= 'F')
			{
				a_outtxt[size1] = s_inchar[size1] - 'A'+10;
			}
			else if(	s_inchar[size1]>='a' && s_inchar[size1] <= 'f')
			{
				a_outtxt[size1] = s_inchar[size1] - 'a'+10;
			}

		}
	 for( size1=0,i=0;size1<s_len; size1++,i++)
	 {
			a_outtxt[i]=(a_outtxt[size1]<<4)|a_outtxt[++size1];			
	 }
	  a_outtxt[i] = '\0';
	    
}

uint16_t str_to_hex16(uint8_t *buf, uint8_t * format, uint16_t us_length)
{
	uint8_t tempcode;
	uint16_t uslength = us_length * 2,us_count = 0,us_data;

	for(us_data = 0;us_count < uslength; us_count += 2,us_data++)
	{
		tempcode = format[us_data] >> 4;

		if(tempcode <= 9)
		{
			buf[us_count] = tempcode + '0';
		}
		else
		{
			buf[us_count] = tempcode - 10 + 'A';
		}
		tempcode = format[us_data] & 0X0F;
		if(tempcode <= 9)
		{
			buf[us_count+1] = tempcode + '0';
		}
		else
		{
			buf[us_count+1] = tempcode - 0X0A + 'A';
		}
	}
	buf[uslength] = '\0';
	return uslength;
}

uint16_t buf_ab_2_uint16(uint8_t *buf)
{
	return (((uint16_t)buf[0] << 8) | buf[1]);
}

uint16_t buf_ba_2_uint16(uint8_t *buf)
{
	return (((uint16_t)buf[1] << 8) | buf[0]);
}

int16_t buf_ab_2_int16(uint8_t *buf)
{
	return (((int16_t)buf[0] << 8) | buf[1]);
}

int16_t buf_ba_2_int16(uint8_t *buf)
{
	return (((int16_t)buf[1] << 8) | buf[0]);
}


uint32_t buf_abcd_2_uint32(uint8_t *buf)
{
	return (((uint32_t)buf[0] << 24) | ((uint32_t)buf[1] << 16) | ((uint32_t)buf[2] << 8) | buf[3]);
}

uint32_t buf_cdab_2_uint32(uint8_t *buf)
{
	return (((uint32_t)buf[2] << 24) | ((uint32_t)buf[3] << 16) | ((uint32_t)buf[0] << 8) | buf[1]);
}

uint32_t buf_badc_2_uint32(uint8_t *buf)
{
	return (((uint32_t)buf[1] << 24) | ((uint32_t)buf[0] << 16) | ((uint32_t)buf[3] << 8) | buf[2]);
}

uint32_t buf_dcba_2_uint32(uint8_t *buf)
{
	return (((uint32_t)buf[3] << 24) | ((uint32_t)buf[2] << 16) | ((uint32_t)buf[1] << 8) | buf[0]);
}

int32_t buf_abcd_2_int32(uint8_t *buf)
{
	return (((int32_t)buf[0] << 24) | ((int32_t)buf[1] << 16) | ((int32_t)buf[2] << 8) | buf[3]);
}

int32_t buf_cdab_2_int32(uint8_t *buf)
{
	return (((int32_t)buf[2] << 24) | ((int32_t)buf[3] << 16) | ((int32_t)buf[0] << 8) | buf[1]);
}

int32_t buf_badc_2_int32(uint8_t *buf)
{
	return (((int32_t)buf[1] << 24) | ((int32_t)buf[0] << 16) | ((int32_t)buf[3] << 8) | buf[2]);
}

int32_t buf_dcba_2_int32(uint8_t *buf)
{
	return (((int32_t)buf[3] << 24) | ((int32_t)buf[2] << 16) | ((int32_t)buf[1] << 8) | buf[0]);
}


float buf_abcd_2_float(uint8_t *buf)
{
	uint8_t *rec;
	float res = 0;
	rec = (uint8_t *)&res;
	*rec = buf[3];rec++;
	*rec = buf[2];rec++;
	*rec = buf[1];rec++;
	*rec = buf[0];

	return res;
}

float buf_cdab_2_float(uint8_t *buf)
{
	uint8_t *rec;
	float res = 0;
	rec = (uint8_t *)&res;
	*rec = buf[1];rec++;
	*rec = buf[0];rec++;
	*rec = buf[3];rec++;
	*rec = buf[2];

	return res;
}

float buf_badc_2_float(uint8_t *buf)
{
		uint8_t *rec;
	float res = 0;
	rec = (uint8_t *)&res;
	*rec = buf[2];rec++;
	*rec = buf[3];rec++;
	*rec = buf[0];rec++;
	*rec = buf[1];

	return res;
}

float buf_dcba_2_float(uint8_t *buf)
{
	uint8_t *rec;
	float res = 0;
	rec = (uint8_t *)&res;
	*rec = buf[0];rec++;
	*rec = buf[1];rec++;
	*rec = buf[2];rec++;
	*rec = buf[3];

	return res;
}
