# Keil uVision project new_tp500.uvprojx, settings and files
target new_tp500 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: FM33LG04X FMSH
  pack: Keil.FM33LG0XX_DFP.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: tp500 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FM33LG0XX,USE_FULL_ASSERT
  c include: ../Drivers/CMSIS/Inculde;../Drivers/FM33LG0xx_FL_Driver/Inc;../Drivers/CMSIS/Device/FM/FM33xx/Include;../MF-config/Inc;../Inc;..\APP\inc;..\HARD\inc;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x2000 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lg0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.c
    ../Inc/: fm33_assert.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
  group Drivers/FM33LG0xx_FL_Driver
    ../Drivers/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl_svd.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_exti.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_pgl.c fm33lg0xx_fl_rtcb.c fm33lg0xx_fl_vrefp.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_vao.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_opa.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_wwdt.c fm33lg0xx_fl_u7816.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_can.c fm33lg0xx_fl_bstim16.c
  group APP
    ../APP/src/: device_info.c display.c hist_storage.c pwr_manage.c sensor.c server.c sys_setting.c touch_key.c
  group HARD
    ../HARD/src/: ad.c Air780E.c AT.c esp32_c5.c flash.c iwdg.c l76k.c myiic.c oled.c sd3078.c tool.c usart.c w25qxx.c ymodem.c delay.c modbus_tcp.c
  group FREERTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
